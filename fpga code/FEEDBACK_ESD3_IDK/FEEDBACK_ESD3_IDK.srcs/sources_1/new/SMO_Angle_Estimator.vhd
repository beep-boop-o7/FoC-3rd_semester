
----------------------------------------------------------------------------------
-- Design Name: FPGA-based FOC Controller
-- Module Name: SMO_Angle_Estimator
--
-- Description:
-- Calculates the electrical rotor angle from the estimated alpha-beta
-- back-EMF generated by Motor_Model.
--
-- Uses a fixed-point CORDIC vectoring algorithm to calculate atan2.
--
-- theta_est:
--   8-bit electrical angle, where 0-255 represents 0-360 degrees.
--
-- omega_est:
--   Signed angle change per sample, in 8-bit angle counts/sample,
--   represented in Q16 format.
--
----------------------------------------------------------------------------------

library IEEE;
use IEEE.STD_LOGIC_1164.ALL;
use IEEE.NUMERIC_STD.ALL;

entity SMO_Angle_Estimator is
    generic (
        -- Minimum back-EMF component magnitude before accepting an angle.
        -- This is in the same numerical scale as ealpha_est/ebeta_est.
        MIN_EMF_COMPONENT : positive := 8;

        -- Rotor angle correction in 8-bit angle units.
        -- 192 = -90 degrees (equivalent to +270 degrees).
        -- This must be verified for your motor/model conventions.
        ROTOR_OFFSET : integer := 192
    );
    port (
        clk : in std_logic;
        reset : in std_logic;

        sample_enable : in std_logic;

        -- Estimated back-EMF from Motor_Model
        ealpha_est : in signed(19 downto 0);
        ebeta_est  : in signed(19 downto 0);

        -- Estimated rotor position and speed
        theta_est : out unsigned(7 downto 0);
        omega_est : out signed(31 downto 0);

        angle_valid : out std_logic
    );
end SMO_Angle_Estimator;


architecture Behavioral of SMO_Angle_Estimator is

    signal theta_reg : unsigned(7 downto 0) := (others => '0');
    signal omega_reg : signed(31 downto 0) := (others => '0');

    signal valid_reg : std_logic := '0';

    signal angle_initialized : std_logic := '0';


    function cordic_atan2(
        x_in : signed(19 downto 0);
        y_in : signed(19 downto 0)
    ) return unsigned is

        variable x : signed(31 downto 0);
        variable y : signed(31 downto 0);

        variable x_old : signed(31 downto 0);
        variable y_old : signed(31 downto 0);

        variable z : integer := 0;

        variable angle_result : unsigned(15 downto 0);

        type atan_table_type is array (0 to 14) of integer;

        constant ATAN_TABLE : atan_table_type := (
            8192,
            4836,
            2555,
            1297,
            651,
            326,
            163,
            81,
            41,
            20,
            10,
            5,
            3,
            1,
            1
        );

    begin

        x := resize(x_in, 32);
        y := resize(y_in, 32);

        z := 0;

        -- No meaningful angle when both components are zero.
        if (x = 0) and (y = 0) then
            return to_unsigned(0, 16);
        end if;

        -- Move negative-X vectors into the positive-X half-plane.
        if x < 0 then
            x := -x;
            y := -y;
            z := 32768;
        end if;

        -- CORDIC vectoring iterations
        for i in 0 to 14 loop

            x_old := x;
            y_old := y;

            if y_old > 0 then

                x := x_old + shift_right(y_old, i);
                y := y_old - shift_right(x_old, i);

                z := z + ATAN_TABLE(i);

            elsif y_old < 0 then

                x := x_old - shift_right(y_old, i);
                y := y_old + shift_right(x_old, i);

                z := z - ATAN_TABLE(i);

            end if;

        end loop;

        -- Convert signed angle to a 16-bit circular angle.
        angle_result := to_unsigned(z mod 65536, 16);

        return angle_result;

    end function;


begin


    -- MAIN ESTIMATOR PROCESS


    process(clk)

        variable angle_raw : unsigned(15 downto 0);

        variable theta_next : unsigned(7 downto 0);

        variable delta_theta : signed(7 downto 0);

        variable alpha_abs : integer;
        variable beta_abs  : integer;

    begin

        if rising_edge(clk) then

            if reset = '1' then

                angle_initialized <= '0';
                theta_reg <= (others => '0');
                omega_reg <= (others => '0');
                valid_reg <= '0';

            else

                valid_reg <= '0';

                if sample_enable = '1' then

                    alpha_abs := abs(to_integer(ealpha_est));
                    beta_abs  := abs(to_integer(ebeta_est));

                    -- Only calculate a new angle when the back-EMF is large

                    if (alpha_abs >= MIN_EMF_COMPONENT) or
                       (beta_abs >= MIN_EMF_COMPONENT) then

                        -- Calculate back-EMF vector angle.
                        angle_raw := cordic_atan2(
                            ealpha_est,
                            ebeta_est
                        );

                        -- Convert 16-bit angle to 8-bit angle.

                        theta_next := angle_raw(15 downto 8) + to_unsigned(ROTOR_OFFSET mod 256, 8);
                            

                        -- Calculate wrapped angle difference.

                            if angle_initialized = '0' then
                            
                                theta_reg <= theta_next;
                                omega_reg <= (others => '0');
                                angle_initialized <= '1';
                            
                            else
                            
                                -- Calculate wrapped angle difference.
                                delta_theta := signed(theta_next - theta_reg);
                            
                                -- Speed in Q16 angle counts/sample.
                                omega_reg <= shift_left(resize(delta_theta, 32),16);
                            
                                theta_reg <= theta_next;
                            
                            end if;
                            
                            valid_reg <= '1';

                    end if;

                end if;

            end if;

        end if;

    end process;


    -- OUTPUTS

    theta_est  <= theta_reg;
    omega_est  <= omega_reg;
    angle_valid <= valid_reg;

end Behavioral;
